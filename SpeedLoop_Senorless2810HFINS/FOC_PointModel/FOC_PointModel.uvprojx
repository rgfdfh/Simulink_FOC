# Keil uVision project FOC_PointModel.uvprojx, settings and files
target FOC_PointModel (6230000::V6.23::ARMCLANG)
  device: LKS32MC074DOF8Q8 Linko
  pack: Linko.LKS07x.1.1.8
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FOC_PointModel (library)
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\MATLAB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group MATLAB
    ./MATLAB/: FOC_PointModel.c FOC_PointModel_data.c
