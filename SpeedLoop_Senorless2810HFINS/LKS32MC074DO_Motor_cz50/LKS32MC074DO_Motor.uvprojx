# Keil uVision project LKS32MC074DO_Motor.uvprojx, settings and files
target LKS32MC074DO_Motor (6230000::V6.23::ARMCLANG)
  device: LKS32MC074DOF8Q8 Linko
  pack: Linko.LKS07x.1.1.8
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LKS32MC074DO_Motor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\lks32mc07x_periph_driver\Include;.\Hardware\Include;.\User\Include;.\MATLAB;.\SEGGER_RTT
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\Objects\LKS32MC074DO_Motor.sct
  group Core
    ./Core/: main.c
  group Hardware
    ./Hardware/Source/: gpio.c mcpwm.c system.c timer.c adc.c opa.c
  group User
    ./User/Source/: dshot.c AAA.c dshot_bidir.c
  group lks32mc07x_periph_driver
    ./lks32mc07x_periph_driver/Source/: lks32mc07x_adc.c lks32mc07x_can.c lks32mc07x_clu.c lks32mc07x_cmp.c lks32mc07x_crc.c lks32mc07x_dac.c lks32mc07x_dma.c lks32mc07x_dsp.c lks32mc07x_exti.c lks32MC07x_flash.c lks32mc07x_gpio.c lks32mc07x_hall.c lks32mc07x_i2c.c lks32mc07x_mcpwm.c lks32mc07x_nvr.lib lks32mc07x_opa.c lks32mc07x_qep.c lks32mc07x_sif.c lks32mc07x_spi.c lks32mc07x_sys.c lks32mc07x_tim.c lks32mc07x_tmp.c lks32mc07x_uart.c lks32mc07x_wake.c startup_lks32mc07x.s
  group MATLAB
    ./MATLAB/: FOC_PointModel.c FOC_PointModel_data.c
  group SEGGER_RTT
    ./SEGGER_RTT/: rtt_debug.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: CMSIS:CORE 6.1.0
