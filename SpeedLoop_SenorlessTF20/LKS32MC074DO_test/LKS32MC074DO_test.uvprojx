# Keil uVision project LKS32MC074DO_test.uvprojx, settings and files
target lks32mc07x_StdPeriph (6230000::V6.23::ARMCLANG)
  device: LKS32MC074DOF8Q8 Linko
  pack: Linko.LKS07x.1.1.8
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LKS32MC074DO_test +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Include;.\lks32mc07x_periph_driver\Include;.\SEGGER_RTT;.\MATLAB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./Source/: main.c delay.c hardware_init.c interrupt.c
    ./Include/: delay.h hardware_config.h hardware_init.h interrupt.h
  group Periph_drivers
    ./lks32mc07x_periph_driver/Source/: lks32mc07x_sys.c lks32mc07x_gpio.c lks32mc07x_adc.c lks32mc07x_can.c lks32mc07x_cmp.c lks32mc07x_dac.c lks32mc07x_dma.c lks32mc07x_dsp.c lks32mc07x_exti.c lks32MC07x_flash.c lks32mc07x_hall.c lks32mc07x_mcpwm.c lks32mc07x_opa.c lks32mc07x_qep.c lks32mc07x_sif.c lks32mc07x_tim.c lks32mc07x_tmp.c lks32mc07x_wake.c lks32mc07x_uart.c lks32mc07x_i2c.c lks32mc07x_spi.c lks32mc07x_nvr.lib startup_lks32mc07x.s lks32mc07x_clu.c
  group SEGGER_RTT
    ./SEGGER_RTT/: rtt_debug.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group MATLAB
    ./MATLAB/: FOC_PointModel.c FOC_PointModel_data.c
software components: CMSIS:CORE 6.1.0
